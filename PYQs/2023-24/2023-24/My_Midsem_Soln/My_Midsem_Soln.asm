ORG 0H
LJMP MAIN
ORG 100H

MAIN:
	MOV 70H, #216
	MOV 71H, #173 
	MOV R2, #00H
	
CALL PVT_KEY_CALC
HERE: SJMP HERE

ORG 130H
		
	PVT_KEY_CALC:
		MOV R0, #00H
		LOOP:
			CLR C
			INC R0
			MOV A, 70H
			MOV B, R0
			MUL AB
			ADD A, #01H
			TEST:
				MOV B, 71H
				DIV AB
				CJNE B, #00H, LOOP
				MOV 72H, A
		RET
END