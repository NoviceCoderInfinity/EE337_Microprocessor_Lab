ORG 0H
LJMP MAIN
ORG 100H

MAIN:
MOV R1, #61H
CALL MODADD
CALL MODSUB

HERE: SJMP HERE
ORG 130H

MODADD:
MOV A, 70H
ADD A, 71H // A = 70H + 71H
MOV 72H, A
LOOP:
    SUBB A, R1 // A = A - R1
    JNC LOOP
    ADD A, R1 // A = A + R1
MOV 72H, A
RET

MODSUB:
CLR C
MOV A, 70H
SUBB A, 71H // A = 70H - 71H
MOV 73H, A
TEMP:
	JNC LOOP1
	ADDC A, R1
LOOP1:
    SUBB A, R1 // A = A - R1
    JNC LOOP1
    ADD A, R1 // A = A + R1
MOV 73H, A
RET

END