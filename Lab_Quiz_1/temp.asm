ORG 0H
LJMP MAIN
ORG 100H
	
MAIN:
CALL XYZ
HERE: SJMP HERE
ORG 130H

XYZ:
	MOV 50H, #1BH
	MOV 51H, #0FH
	MOV A, 50H
	MOV B, 51H
	
S:
	SUBB A, B
	JC HERE1
	JZ HERE2
	MOV R2, B
	CJNE R2, #00H, S
	JMP ENDING

HERE1:
	CPL A
	INC A

HERE2:

	XRL A, B
	XRL B, A
	XRL A,B
	MOV R2 , B
	CJNE R2 , #00H , S
	JMP ENDING

ENDING: MOV 52H , A
RET
END