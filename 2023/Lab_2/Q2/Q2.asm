ORG 0H
LJMP MAIN
ORG 100H
MAIN:
CALL DET
HERE: SJMP HERE
ORG 130H

DET:
MOV A, 60H
MOV B, 63H
MUL AB
MOV A, 71H
MOV B, 70H

MOV A, 61H
MOV B, 62H
MUL AB

MOV R0, A
MOV R1, B

MOV A, 71H
MOV B, 70H

SUBB A, R0
SUBB B, R1

MOV A, 71H
MOV B, 70H
RET
END